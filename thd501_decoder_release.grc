options:
  parameters:
    generate_options: no_gui
    id: thd501_decoder_release
    output_language: python
    run_options: run
    title: THD501 Decoder
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 1 / symbol_time
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 426.025e6
  states: {}
- name: symbol_time
  id: variable
  parameters:
    value: '2000e-6'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: timing_ted_gain
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: down_samp_rate / (2*math.pi*deviation)
  states: {}
- name: base_samp_rate
  id: parameter
  parameters:
    label: capture sample rate
    type: eng_float
    value: 240e3
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: down_samp_rate / baud_rate
    ted_gain: timing_ted_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: down_samp_rate
  id: parameter
  parameters:
    label: down sampling rate
    type: eng_float
    value: 24e3
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import json

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="THD501 Decoder",
                  in_sig=[],
                  out_sig=[])
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_pdu)

          def parse_data(self, data):
              humid_digit10 = data[2] >> 4
              humid_digit1  = data[2] & 0xf
              humid = humid_digit10*10 + humid_digit1 if (0 <= humid_digit10 <= 9) and (0 <= humid_digit1 <= 9) else None
              temp_digit10 = data[4] & 0xf
              temp_digit1  = data[5] >> 4
              temp_frac1   = data[5] & 0xf
              temp_sign    = -1 if data[3] & 0x8 else 1
              temp = temp_sign * (temp_digit10*10 + temp_digit1 + temp_frac1/10.0) if (0 <= temp_digit10 <= 9) and (0 <= temp_digit1 <= 9) and (0 <= temp_frac1 <= 9) else None
              absolute_humid = None
              if (temp is not None) and (humid is not None):
                  e = 6.11 * 10**((7.5*temp)/(237.3+temp))
                  ep = e * humid/100.0
                  absolute_humid = (217 * ep) / (273.15 + temp)
              return {'temperature': temp, 'humidity':humid, 'absolute_humidity': absolute_humid}

          def save(self, data):
              # debug print
              print("THD501Decoder " + json.dumps(data))

          def handle_pdu(self, pdu):
              EXPECT_PREAMBLE = b'\xd2\x2b'
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)
              bits = pmt.u8vector_elements(data)
              if len(bits) != 112: return
              payload = int(''.join(map(str, bits)), 2).to_bytes(len(bits)//8, byteorder='big')
              data0 = payload[2:8]
              data0_inv = bytes(x ^ 0xFF for x in data0)
              data1 = payload[8:14]
              self.save({
                  'raw'    : payload.hex(),
                  'isValid': (EXPECT_PREAMBLE == payload[0:2]) and (data0_inv == data1),
                  'data0'  : self.parse_data(data0_inv),
                  'data1'  : self.parse_data(data1),
              })
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: deviation - offset_tuning_freq
    decim: round(base_samp_rate / down_samp_rate)
    samp_rate: base_samp_rate
    taps: firdes.low_pass(1.0, down_samp_rate, 2*deviation, 2*deviation)
    type: ccc
  states: {}
- name: offset_tuning_freq
  id: parameter
  parameters:
    label: offset tuning frequency
    type: eng_float
    value: '0'
  states: {}
- name: ppm_correction
  id: parameter
  parameters:
    label: frequency correction (ppm)
    type: eng_float
    value: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: int((down_samp_rate / baud_rate) * rrc_filter_coe)
    samp_rate: down_samp_rate
    sym_rate: baud_rate*2
    type: fir_filter_fff
  states: {}
- name: rrc_filter_coe
  id: parameter
  parameters:
    label: rrc filter coe
    type: eng_float
    value: '10'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: samp_bw
    corr0: ppm_correction
    freq0: freq + offset_tuning_freq
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: base_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: samp_bw
  id: parameter
  parameters:
    label: capture bandwidth
    type: eng_float
    value: 2.5e3
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: '112'
    sync: '"01010101010101010101010101010101"'
    threshold: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', virtual_sink_1, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_quadrature_demod_cf_1, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [satellites_sync_to_pdu_0, out, epy_block_0, in]
- [virtual_source_0, '0', root_raised_cosine_filter_0, '0']
- [virtual_source_1, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
